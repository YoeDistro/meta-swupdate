require swupdate.inc

DEFAULT_PREFERENCE = "-1"

SRCREV ?= "e0e9809ae9159ca0ef124bf780d4c58c9fc75302"
PV = "2025.12+git${SRCPV}"
